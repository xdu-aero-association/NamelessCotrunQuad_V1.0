# IAR project NamelessCotrunQuad.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; ARM_MATH_CM3
  ICCARM.CCIncludePath2: Chip\inc; Chip\CMSIS; User; User\Driver\Inc; User\Controler\Inc; User\AHRS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: NamelessCotrunQuad.bin
  ILINK.IlinkOutputFile: NamelessCotrunQuad.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: Chip\inc; Chip\CMSIS; User; User\Driver\Inc; User\Controler\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group Chip/Inc
    Chip/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Chip/Src
    Chip/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    Chip/CMSIS/: system_stm32f10x.c
  group CMSIS/Startup
    Chip/CMSIS/startup/: startup_stm32f10x_hd.s
  group User
    User/: Filter.c Headfile.h main.c stm32f10x_conf.h stm32f10x_it.c
  group User/AHRS
    User/AHRS/: Advanced_AHRS.c arm_math.h DoubleMatrix.c EKF.c EKF.h FastMath.c Matrix.c Quaternion.c
  group User/Controler/Inc
    User/Controler/Inc/: ADRC.h Calibration.h PID.h SINS.h
  group User/Controler/Src
    User/Controler/Src/: Calibration.s IMU.c NamelessCorun_Ctrl.c PID.c SINS.s
  group User/Driver/Inc
    User/Driver/Inc/: DELAY.h FBM320.h SPI2.h SPL06_001.h SYSTEM.h US_100.h USART.h
  group User/Driver/Src
    User/Driver/Src/: Bling.c delay.c FBM320.c FLASH.c GPS.c HMC5883.c IIC.c IST8310.s KEY.c MPU6050.s MS5611.c NRF24L01.c OLED.c PPM.c PWM.c PX4FLOW.c SPI2.c SPL06_001.c SYSTEM.c TIME.c Time_Cnt.c US_100.c USART.c VL53L0X.c
